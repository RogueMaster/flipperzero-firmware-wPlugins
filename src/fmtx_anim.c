#include "fmtx_anim.h"

#include <furi_hal_random.h>

static uint32_t dice;
static uint32_t run = ~0U;
static bool skip;

static const uint8_t dolph[] = {
    0x01, 0x00, 0x2a, 0x01, 0x00, 0x78, 0x01, 0xbf, 0xd1, 0xf0, 0x29, 0xf0, 0x20, 0x3e, 0x08, 0x08,
    0x18, 0xa6, 0x00, 0x21, 0x83, 0x01, 0x8a, 0x18, 0x02, 0x18, 0xc0, 0x18, 0xa0, 0x40, 0x21, 0x90,
    0x01, 0x88, 0x30, 0x54, 0x00, 0x10, 0xe0, 0x01, 0x24, 0x03, 0x20, 0x49, 0x04, 0x4c, 0x2e, 0x61,
    0xf2, 0x03, 0x1c, 0xf2, 0x09, 0x00, 0x88, 0x01, 0x8a, 0x84, 0x06, 0x5c, 0x0c, 0x22, 0x01, 0x08,
    0x21, 0x0e, 0x02, 0x31, 0x09, 0x03, 0x0c, 0x26, 0x11, 0x80, 0x92, 0x01, 0x87, 0x09, 0x10, 0x03,
    0x14, 0x46, 0x01, 0xc4, 0x88, 0x44, 0x00, 0xc7, 0x44, 0x03, 0x2d, 0x1a, 0x41, 0x20, 0x03, 0x1c,
    0xa8, 0x0c, 0xb3, 0x69, 0x05, 0x00, 0x60, 0x20, 0x61, 0x8d, 0xf8, 0x0b, 0xe3, 0x81, 0x21, 0x8c,
    0x37, 0xc0, 0x5f, 0x1a, 0x10, 0x18, 0x60, 0xe9, 0x02, 0x9e, 0x21, 0x46, 0x07, 0xf0, 0x3f, 0x14,
    0x50, 0x22, 0x3f, 0x08, 0x18, 0x18, 0x61, 0x40, 0x21, 0xe8, 0x7f, 0xc1, 0xc2, 0x61, 0x10, 0x32,
    0x29, 0x0f, 0xfe, 0x03, 0x18, 0x70, 0x08, 0x61, 0x13, 0xc8, 0x04, 0x7c, 0x0c, 0x42, 0xc1, 0xb0,
    0x60, 0x17, 0xa4, 0x17, 0x11, 0x00, 0xc1, 0x46, 0x66, 0x9e, 0x18, 0x3b, 0x29, 0x1a, 0x46, 0xd5,
    0x35, 0x00, 0x90, 0x4c, 0x0c, 0x61, 0xe2, 0x22, 0x9c, 0x2c, 0x0c, 0x98, 0x08, 0x2b, 0xac, 0x8d,
    0xe3, 0xc0, 0x81, 0x33, 0x08, 0x0c, 0x34, 0x08, 0x2f, 0x01, 0xea, 0x7a, 0x01, 0xe0, 0xb9, 0x0e,
    0xa0, 0x04, 0x11, 0xc8, 0xbc, 0x87, 0x60, 0x4d, 0x11, 0x38, 0x81, 0x86, 0xb1, 0x00, 0xb5, 0x4c,
    0x00, 0xc5, 0xac, 0x80, 0x75, 0x28, 0x20, 0x62, 0xaa, 0x40, 0x35, 0x18, 0x38, 0x08, 0x18, 0x65,
    0x42, 0x41, 0x87, 0xc0, 0x80, 0xc3, 0x15, 0x19, 0x0c, 0x7b, 0xf9, 0x5f, 0x29, 0x15, 0x02, 0xfb,
    0x00, 0x12, 0x08, 0xd8, 0x74, 0x1f, 0xa8, 0x09, 0x30, 0x40, 0x05, 0xf5, 0x83, 0x9a, 0x08, 0x00,
    0x3e, 0xaf, 0xfa, 0x2c, 0x96, 0xe4, 0x21, 0x10, 0x01, 0xe8, 0x33, 0xc0, 0x64, 0xa0, 0x65, 0x40,
    0xc9, 0x00, 0xcd, 0x01, 0x96, 0x20, 0xe9, 0x24, 0x89, 0x81, 0xb5, 0x10, 0x20, 0x66,
};

static const uint8_t uv5r[] = {
    0x01, 0x00, 0x93, 0x00, 0xc0, 0x41, 0xc0, 0x63, 0xc0, 0x87, 0x80, 0xfc, 0x07, 0x7f, 0x08, 0x18,
    0x0c, 0x7f, 0x10, 0x70, 0x1c, 0x83, 0xc7, 0xc1, 0x9f, 0xfc, 0xc1, 0xfc, 0x15, 0xff, 0xd4, 0x1f,
    0xe1, 0xff, 0xff, 0xc1, 0xe1, 0x02, 0x21, 0x84, 0x79, 0x00, 0xe3, 0x13, 0x8a, 0x01, 0xc6, 0x28,
    0x03, 0xb8, 0xb0, 0x0c, 0xa2, 0xe0, 0x36, 0xf3, 0x07, 0xca, 0x08, 0x07, 0x19, 0x80, 0x0c, 0xfc,
    0xc6, 0xf1, 0x98, 0x45, 0xc6, 0x83, 0x30, 0xeb, 0xc2, 0xc0, 0x65, 0xcb, 0xee, 0xcd, 0x41, 0x67,
    0xe7, 0xd3, 0xee, 0xe6, 0x68, 0x62, 0x98, 0x41, 0xee, 0x17, 0x79, 0xbf, 0x18, 0x0e, 0x5c, 0x4f,
    0x07, 0xba, 0x6c, 0x2b, 0x38, 0x37, 0x40, 0x3e, 0x21, 0x72, 0x88, 0x71, 0xe0, 0x78, 0x08, 0x9f,
    0x18, 0x06, 0x5c, 0x48, 0x18, 0x2c, 0x42, 0xe5, 0x10, 0x86, 0x00, 0xc6, 0x31, 0xcc, 0xbd, 0xfb,
    0xe3, 0x20, 0x33, 0x05, 0xf8, 0x2f, 0xc0, 0x67, 0x1c, 0x05, 0x94, 0xe0, 0x06, 0x30, 0xcb, 0x80,
    0x0c, 0x60, 0xde, 0x04, 0x58, 0xc0, 0xc0,
};

static void notes(Canvas* c, uint8_t f, uint32_t z) {
    int y;

    // f=3 draws one note; f=4 draws a pair and sometimes the single too.
    if(f == 4U) {
        y = 27 + (int)((z >> 1) % 21U) - 10;
        canvas_draw_box(c, 71, y, 2, 1);
        canvas_draw_box(c, 70, y + 1, 4, 2);
        canvas_draw_box(c, 71, y + 3, 2, 1);
        canvas_draw_line(c, 73, y - 6, 73, y + 2);
        canvas_draw_box(c, 79, y + 1, 2, 1);
        canvas_draw_box(c, 78, y + 2, 4, 2);
        canvas_draw_box(c, 79, y + 4, 2, 1);
        canvas_draw_line(c, 81, y - 5, 81, y + 3);
        canvas_draw_line(c, 73, y - 6, 81, y - 5);
        if(!(dice & 1U)) return;
    }

    y = 35 + (int)((z >> 9) % 21U) - 10;
    canvas_draw_box(c, 89, y, 2, 1);
    canvas_draw_box(c, 88, y + 1, 4, 2);
    canvas_draw_box(c, 89, y + 3, 2, 1);
    canvas_draw_line(c, 91, y - 6, 91, y + 2);
    canvas_draw_line(c, 91, y - 6, 95, y - 4);
    canvas_draw_line(c, 95, y - 4, 95, y - 2);
}

void txrand(void) {
    dice = furi_hal_random_get();
    run = ~0U;
    skip = false;
}

void txcancel(uint32_t ms) {
    uint32_t p = ms % 20000U;
    if(p >= 2000U && p < 7000U) skip = true;
}

void txpic(Canvas* c, uint8_t f) {
    uint32_t z = f == 3U ? dice : (dice << 16) | (dice >> 16);

    canvas_clear(c);

    if(f < 3U) {
        for(uint8_t i = 0; i <= f; i++)
            canvas_draw_circle(c, 61, 32, 4U + i * 5U);
        canvas_set_color(c, ColorWhite);
        canvas_draw_box(c, 0, 0, 61, 64);
        canvas_set_color(c, ColorBlack);
    }

    canvas_draw_bitmap(c, 0, 0, 51, 64, dolph);
    canvas_draw_bitmap(c, 98, 1, 30, 61, uv5r);

    if(f >= 3U) {
        for(uint8_t y = 18; y <= 24; y++)
            for(uint8_t x = 5; x <= 25; x++)
                if((x + y) & 1U) canvas_draw_dot(c, 98 + x, 1 + y);

        notes(c, f, z);
    }
}

bool txdraw(Canvas* c, uint32_t ms) {
    // Five frames repeat twice from seconds 2 through 7 of each 20-second slot.
    uint32_t p = ms % 20000U;
    uint32_t n = ms / 20000U;
    if(p < 2000U || p >= 7000U) {
        skip = false;
        return false;
    }
    if(skip) return false;
    if(n != run) {
        run = n;
        dice = furi_hal_random_get();
    }
    txpic(c, ((p - 2000U) / 500U) % 5U);

    return true;
}
